options:
  parameters:
    generate_options: qt_gui
    id: GGBLUE
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: frequency
  id: variable
  parameters:
    value: 2.426e9
  states: {}
- name: ntaps
  id: variable
  parameters:
    value: 11*sps
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: rot_inc
  id: variable
  parameters:
    value: 2*3.141596 * (tone_hz) / (samp_rate)
  states: {state: disabled}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(1.0, samp_rate, symbol_rate, 0.35, 11*sps)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: samp_rate/sps
  states: {}
- name: tone_hz
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: tx_amp
  id: variable
  parameters:
    value: '0.25'
  states: {}
- name: variable_rrc_filter_taps_0
  id: variable_rrc_filter_taps
  parameters:
    alpha: rolloff
    gain: '1.0'
    ntaps: ntaps
    samp_rate: samp_rate
    sym_rate: symbol_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SQR_WAVE
  states: {state: disabled}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: tx_amp
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: rot_inc
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1]'
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: '[1.0]'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: '[1.0]'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: '[1.0]'
    type: ccc
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: rrc_taps
    type: fcc
  states: {state: disabled}
- name: osmosdr_source_0_0
  id: osmosdr_source
  parameters:
    args: hackrf=0
    bb_gain0: '0'
    bw0: 2e6
    freq0: frequency
    gain0: '14'
    gain_mode0: 'False'
    if_gain0: '16'
    sample_rate: 2e6
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0_0_0
  id: osmosdr_source
  parameters:
    args: hackrf=1
    bb_gain0: '0'
    bw0: 2e6
    freq0: frequency
    gain0: '14'
    gain_mode0: 'False'
    if_gain0: '16'
    sample_rate: 2e6
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0_0_1
  id: osmosdr_source
  parameters:
    args: hackrf=2
    bb_gain0: '0'
    bw0: 2e6
    freq0: frequency
    gain0: '14'
    gain_mode0: 'False'
    if_gain0: '16'
    sample_rate: 2e6
    sync: sync
    type: fc32
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 1e6
    fc: frequency
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 1e6
    fc: frequency
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 1e6
    fc: frequency
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: 1e6
    center_freq0: frequency
    clock_source0: internal
    dev_addr: addr=192.168.10.3
    gain0: '35'
    samp_rate: 1e6
    sync: none
    type: fc32
  states: {state: disabled}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_push_sink_0_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5556
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_push_sink_0_1
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5557
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_const_xx_0, '0', blocks_rotator_cc_0, '0']
- [blocks_multiply_xx_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_rotator_cc_0, '0', blocks_multiply_xx_0, '0']
- [blocks_vector_source_x_0, '0', interp_fir_filter_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', zeromq_push_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', zeromq_push_sink_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_1, '0', zeromq_push_sink_0_1, '0']
- [interp_fir_filter_xxx_0, '0', blocks_multiply_const_xx_0, '0']
- [osmosdr_source_0_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [osmosdr_source_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [osmosdr_source_0_0_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [osmosdr_source_0_0_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']
- [osmosdr_source_0_0_1, '0', freq_xlating_fir_filter_xxx_0_1, '0']
- [osmosdr_source_0_0_1, '0', qtgui_waterfall_sink_x_0_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
